# Keil uVision project SIMULATOR.uvproj, settings and files
target Target_1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: SIMULATOR +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\drivers;.\inventory;.\state_machine;.\utils
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: main.c
    ./drivers/: dac.c elevator.c keypad.c lcd.c ldr.c motor.c seg7.c stepper.c
    ./inventory/: inventory.c
    ./state_machine/: state_machine.c
    ./utils/: delay.c
    ./startup/: startup_LPC21xx.s
